#include "ssd1306_glyphs.h"

#include <algorithm>
#include <array>
#include <cassert>
#include <string_view>

#include "ssd1306_glyph_assets.h"

namespace {

template <std::size_t N>
uint32_t Fnv1a(std::array<uint8_t, N> glyph) {
    uint32_t hash = 0x811c9dc5;
    for (const uint8_t byte : glyph) {
        hash = (hash ^ byte) * 0x01000193;
    }
    return hash;
}

struct GlyphGolden {
    uint32_t codepoint;
    uint32_t hash;
};

struct AsciiGlyphGolden {
    char value;
    uint32_t hash;
};

}  // namespace

int main() {
    using voicelife::display_esp::internal::LookupAsciiGlyph;
    using voicelife::display_esp::internal::LookupBuiltinMoodGlyph;
    using voicelife::display_esp::internal::LookupFallbackGlyph16;
    using voicelife::display_esp::internal::LookupGlyph16;
    using voicelife::display_esp::internal::LookupMoodGlyph;

    constexpr std::array<AsciiGlyphGolden, 32> kAsciiGoldens = {{
        {'!', 0x92e57dc6}, {'A', 0xae3d0775}, {'B', 0x926a5b62}, {'C', 0xa07cbc79}, {'D', 0x0cf9d9fa},
        {'E', 0xe5380b6d}, {'G', 0xc7c62a19}, {'I', 0x54b1e8d8}, {'K', 0xae5c9319}, {'L', 0x36df2eee},
        {'N', 0x1c33f6d7}, {'O', 0x0872d2d5}, {'R', 0x7210db02}, {'S', 0xcb06837a}, {'T', 0xf452af41},
        {'W', 0x804f46e7}, {'V', 0xf66f529f}, {'Y', 0x7c833407}, {'0', 0x6767117c}, {'1', 0x92f827c8},
        {'2', 0x6c8b4f9c}, {'3', 0x3d070584}, {'4', 0x5f40c67e}, {'5', 0x83a99d42}, {'6', 0xce703144},
        {'7', 0xa64cab7a}, {'8', 0xce994b50}, {'9', 0x68212d18}, {'-', 0xa163990f}, {':', 0x7cda4b5f},
        {'/', 0x28bd14b3}, {' ', 0x1210d00f},
    }};
    for (const AsciiGlyphGolden golden : kAsciiGoldens) {
        assert(Fnv1a(LookupAsciiGlyph(golden.value)) == golden.hash);
    }
    assert((LookupAsciiGlyph('?') == std::array<uint8_t, 5>{0x00, 0x00, 0x00, 0x00, 0x00}));

    constexpr std::array<uint8_t, 32> kUnknownGlyph = {
        0x00, 0xff, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xff, 0x00,
        0x00, 0xff, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xff, 0x00,
    };
    assert(LookupGlyph16(0x10ffff) == kUnknownGlyph);

    constexpr std::array<GlyphGolden, 132> kFallbackGoldens = {{
        {0x7a7a, 0x2c9e205e}, {0x95f2, 0x616f7168}, {0x8046, 0x119e06f3}, {0x542c, 0x3eae1d63}, {0x601d, 0x84e5b3cf},
        {0x8003, 0x70cbb626}, {0x64ad, 0x2e48da17}, {0x62a5, 0x88707fcd}, {0x505c, 0x34d346d3}, {0x6b62, 0x2396e6db},
        {0x91cd, 0xda17ad47}, {0x8fde, 0x0920ed89}, {0x9519, 0xa458133c}, {0x8bef, 0xbebaa756}, {0x5f00, 0x356ce8fb},
        {0x673a, 0x4c5ae6cb}, {0x8054, 0xa7187315}, {0x7f51, 0x7a30b0df}, {0x6536, 0x77c9527a}, {0x5230, 0x77af5465},
        {0x725b, 0x6b709cd2}, {0x8d70, 0x537e8cf6}, {0x4e86, 0x3db5f75b}, {0x65f6, 0x00a2212d}, {0x95f4, 0xd9e30751},
        {0x4f1a, 0x3e807341}, {0x8bae, 0xeb56f868}, {0x521b, 0xe43696cb}, {0x5efa, 0xcdc7904b}, {0x63d0, 0xa3ff93dd},
        {0x9192, 0xbbe86225}, {0x8bb0, 0xae2e6654}, {0x4e8b, 0xbea59a0c}, {0x4eca, 0xac9ef4de}, {0x5929, 0xfbb37f8f},
        {0x660e, 0xfa3047c9}, {0x4e0a, 0x2666dc32}, {0x5348, 0x00d736cc}, {0x4e0b, 0xb2b68d82}, {0x70b9, 0x5b2ff91d},
        {0x534a, 0x82ac5f24}, {0x59cb, 0x0268daef}, {0x7ed3, 0x365ee7da}, {0x675f, 0x6fda2b65}, {0x8bbe, 0x7757b792},
        {0x7f6e, 0x63581bc6}, {0x67e5, 0x7cc901f6}, {0x8be2, 0xea4d40e7}, {0x5217, 0x317f956a}, {0x8868, 0x07138672},
        {0x6dfb, 0x446ad7d4}, {0x52a0, 0xf2919c4b}, {0x5220, 0xae9c1640}, {0x9664, 0x216e8562}, {0x5b8c, 0x693ee26d},
        {0x6210, 0x0182885a}, {0x4fee, 0xddbd21bf}, {0x6539, 0xb23d0aef}, {0x5171, 0x5b61beaf}, {0x6761, 0x588c964f},
        {0x4e2a, 0xbf09ff00}, {0x63a5, 0x3a2f3b9a}, {0x4e2d, 0x401b690a}, {0x5904, 0x07ed3010}, {0x7406, 0xbc1b9e63},
        {0x8bf4, 0x697c5c12}, {0x8bdd, 0x6fc1151d}, {0x51fa, 0xb97eae66}, {0x97f3, 0xde5c8097}, {0x4f60, 0x9efb3462},
        {0x5728, 0xfa62ba62}, {0x5e72, 0x83a26d04}, {0x4ec0, 0xc98bd39a}, {0x4e48, 0x6110cd3f}, {0x518d, 0x00b98551},
        {0x89c1, 0x5c63d16a}, {0x62dc, 0xe5832785}, {0x597d, 0x46bdc215}, {0x7684, 0xd6eb0005}, {0x53ef, 0x89c8566e},
        {0x4ee5, 0x668649ed}, {0x5e2e, 0x6d56741b}, {0x6211, 0x67b23661}, {0x505a, 0x2d2a4e81}, {0x60f3, 0xc8be4f1d},
        {0x89c9, 0xa8830877}, {0x5f97, 0x41213d0e}, {0x5f88, 0x584cbcff}, {0x77e5, 0x225d0d6c}, {0x9053, 0x46529b5d},
        {0x73b0, 0x3f04b04c}, {0x6628, 0x7ae581a0}, {0x795d, 0xdd698714}, {0x4e00, 0x3ceb9e87}, {0x5207, 0x78dc2a96},
        {0x987a, 0x0e7735c7}, {0x5229, 0x0f76f8f2}, {0x5f85, 0x9a92ea62}, {0x547d, 0xb02e6c70}, {0x968f, 0xb4537089},
        {0x51c6, 0x983a0683}, {0x5907, 0x8d257b32}, {0x4e3a, 0xe88620b9}, {0x670d, 0x2520560c}, {0x52a1, 0x88176eb6},
        {0x5173, 0xc64d1692}, {0x65e5, 0x9ce7aa9e}, {0x7a0b, 0xc25cea89}, {0x5f55, 0x030ba953}, {0x5367, 0xd03bb0b6},
        {0x69fd, 0x8505ec85}, {0x6770, 0x376b6448}, {0x4f53, 0x0cd111d1}, {0x98d8, 0x5ba37171}, {0x5f39, 0xaffc3b9f},
        {0x5934, 0x186288b2}, {0x88c5, 0xae0ebf0f}, {0x903c, 0xeddb25d2}, {0x64cd, 0xe8c9f00f}, {0x8d5e, 0xf1a4085c},
        {0x7f8e, 0x82830602}, {0x80a5, 0x2da2b6ed}, {0x54ce, 0xee2416b5}, {0x8e6d, 0x85b98696}, {0x724c, 0x62e71b5e},
        {0x98de, 0xf04bb33a}, {0x613f, 0x71be7623}, {0x6696, 0x29f047f0}, {0x5149, 0x735ac516}, {0x73cd, 0x685374ae},
        {0x8d35, 0x9ee17ada}, {0x8c22, 0x677c6c30},
    }};
    for (const GlyphGolden golden : kFallbackGoldens) {
        assert(Fnv1a(LookupFallbackGlyph16(golden.codepoint)) == golden.hash);
    }

    constexpr std::array<std::pair<std::string_view, uint32_t>, 7> kMoodGoldens = {{
        {"happy", 0x37b43ca1},
        {"sad", 0x4a54c8dd},
        {"thinking", 0x28a25371},
        {"surprised", 0x3f335a2d},
        {"speaking", 0x0805388d},
        {"angry", 0xda4ae355},
        {"neutral", 0x8f220d25},
    }};
    for (const auto& [mood, hash] : kMoodGoldens) {
        assert(Fnv1a(LookupMoodGlyph(mood)) == hash);
        assert(Fnv1a(LookupBuiltinMoodGlyph(mood)) == hash);
    }
    assert(LookupMoodGlyph("unknown") == LookupMoodGlyph("neutral"));
}
