#include "ssd1306_glyphs.h"

#include <algorithm>

#include "font16_provider.h"
#include "ssd1306_glyph_assets.h"

namespace voicelife::display_esp::internal {

std::array<uint8_t, 5> LookupAsciiGlyph(char value) {
    switch (value) {
        case '!':
            return {0x00, 0x00, 0x5f, 0x00, 0x00};
        case 'A':
            return {0x7e, 0x11, 0x11, 0x7e, 0x00};
        case 'B':
            return {0x7f, 0x49, 0x49, 0x36, 0x00};
        case 'C':
            return {0x3e, 0x41, 0x41, 0x22, 0x00};
        case 'D':
            return {0x7f, 0x41, 0x41, 0x3e, 0x00};
        case 'E':
            return {0x7f, 0x49, 0x49, 0x41, 0x00};
        case 'G':
            return {0x3e, 0x41, 0x49, 0x7a, 0x00};
        case 'I':
            return {0x41, 0x7f, 0x41, 0x00, 0x00};
        case 'K':
            return {0x7f, 0x08, 0x14, 0x63, 0x00};
        case 'L':
            return {0x7f, 0x40, 0x40, 0x40, 0x00};
        case 'N':
            return {0x7f, 0x06, 0x18, 0x7f, 0x00};
        case 'O':
            return {0x3e, 0x41, 0x41, 0x3e, 0x00};
        case 'R':
            return {0x7f, 0x09, 0x19, 0x66, 0x00};
        case 'S':
            return {0x46, 0x49, 0x49, 0x31, 0x00};
        case 'T':
            return {0x01, 0x7f, 0x01, 0x01, 0x00};
        case 'W':
            return {0x7f, 0x20, 0x18, 0x20, 0x7f};
        case 'V':
            return {0x07, 0x38, 0x40, 0x38, 0x07};
        case 'Y':
            return {0x03, 0x04, 0x78, 0x04, 0x03};
        case '0':
            return {0x3e, 0x45, 0x49, 0x51, 0x3e};
        case '1':
            return {0x00, 0x42, 0x7f, 0x40, 0x00};
        case '2':
            return {0x62, 0x51, 0x49, 0x49, 0x46};
        case '3':
            return {0x22, 0x49, 0x49, 0x49, 0x36};
        case '4':
            return {0x18, 0x14, 0x12, 0x7f, 0x10};
        case '5':
            return {0x2f, 0x49, 0x49, 0x49, 0x31};
        case '6':
            return {0x3e, 0x49, 0x49, 0x49, 0x32};
        case '7':
            return {0x01, 0x71, 0x09, 0x05, 0x03};
        case '8':
            return {0x36, 0x49, 0x49, 0x49, 0x36};
        case '9':
            return {0x26, 0x49, 0x49, 0x49, 0x3e};
        case '-':
            return {0x08, 0x08, 0x08, 0x08, 0x00};
        case ':':
            return {0x00, 0x36, 0x36, 0x00, 0x00};
        case '/':
            return {0x00, 0x04, 0x08, 0x10, 0x00};
        case ' ':
            return {0x00, 0x00, 0x00, 0x00, 0x00};
        default:
            return {0, 0, 0, 0, 0};
    }
}

// 完整字体资产优先，未命中回退内置点阵，再未命中画方框占位。
std::array<uint8_t, 32> LookupGlyph16(uint32_t codepoint) {
    static const Font16Provider provider;
    std::array<uint8_t, 32> glyph{};
    if (provider.Lookup(codepoint, glyph)) {
        return glyph;
    }
    const auto fallback = LookupFallbackGlyph16(codepoint);
    if (std::any_of(fallback.begin(), fallback.end(), [](uint8_t byte) { return byte != 0; })) {
        return fallback;
    }
    return {0x00, 0xff, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xff, 0x00,
            0x00, 0xff, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xff, 0x00};
}

std::array<uint8_t, 32> LookupMoodGlyph(std::string_view mood) { return LookupBuiltinMoodGlyph(mood); }

}  // namespace voicelife::display_esp::internal
